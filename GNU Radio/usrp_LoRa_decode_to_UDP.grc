options:
  parameters:
    author: FlUxIuS
    copyright: PentHertz
    description: Example of a schema that receive LoRa frames and write to an UDP socket to be decoded with the Scapy Layer
    generate_options: qt_gui
    id: LoRa_usrp_receive_to_UDP
    output_language: python
    title: LoRa Receiver to UDP socket with USRP
  states: {}

blocks:
- name: channel_freq
  id: variable_qtgui_entry
  parameters:
    label: Channel frequency
    type: real
    value: 868e6
  states: {}
- name: freq_slider
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 867e6
    step: '1'
    stop: 869e6
    value: 868e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: Recenter_0
  id: Recenter
  parameters:
    cutoff: 150e3
    decim: '4'
    htd_offset: '-100e3'
    samp_rate: samp_rate
  states: {}
- name: Recenter_0_0
  id: Recenter
  parameters:
    cutoff: 150e3
    decim: '4'
    htd_offset: '-300e3'
    samp_rate: samp_rate
  states: {}
- name: Recenter_0_0_0
  id: Recenter
  parameters:
    cutoff: 150e3
    decim: '4'
    htd_offset: '-500e3'
    samp_rate: samp_rate
  states: {}
- name: Recenter_0_0_0_0
  id: Recenter
  parameters:
    cutoff: 150e3
    decim: '4'
    htd_offset: '-900e3'
    samp_rate: samp_rate
  states: {}
- name: Recenter_0_0_0_0_0
  id: Recenter
  parameters:
    cutoff: 150e3
    decim: '4'
    htd_offset: '-700e3'
    samp_rate: samp_rate
  states: {}
- name: Recenter_0_1
  id: Recenter
  parameters:
    cutoff: 150e3
    decim: '4'
    htd_offset: 100e3
    samp_rate: samp_rate
  states: {}
- name: Recenter_0_1_0
  id: Recenter
  parameters:
    cutoff: 150e3
    decim: '4'
    htd_offset: 300e3
    samp_rate: samp_rate
  states: {}
- name: Recenter_0_1_0_0
  id: Recenter
  parameters:
    cutoff: 150e3
    decim: '4'
    htd_offset: 500e3
    samp_rate: samp_rate
  states: {}
- name: Recenter_0_1_0_0_0
  id: Recenter
  parameters:
    cutoff: 150e3
    decim: '4'
    htd_offset: 700e3
    samp_rate: samp_rate
  states: {}
- name: Recenter_0_1_0_0_0_0
  id: Recenter
  parameters:
    cutoff: 150e3
    decim: '4'
    htd_offset: 900e3
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    minoutbuf: '131072'
    num_inputs: '10'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import socket

      class udp_sender_simple(gr.basic_block):
          def __init__(self, ip="127.0.0.1", port=40868):
              gr.basic_block.__init__(self, name="UDP Raw Sender", in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)
              self.dest_addr = (ip, port)
              self.sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)

          def start(self):
              try:
                  self.sock.sendto(b"--- UDP SENDER START ---", self.dest_addr)
              except:
                  pass
              return True

          def handle_msg(self, msg):
              try:
                  # 1. Uzmi sirove bajtove iz PMT-a
                  serialized = pmt.serialize_str(msg)
                  b_data = serialized if isinstance(serialized, bytes) else serialized.encode('latin-1')

                  # 2. PRONAĐI TOČAN POČETAK (@ znak, tj. 0x40)
                  # Ovo izbacuje onaj '00 12' koji kvari Scapy dekodiranje
                  start_idx = b_data.find(b'\x40')
                  
                  if start_idx != -1:
                      clean_payload = b_data[start_idx:]
                  else:
                      # Ako nema @, preskoči prvi bajt (PMT type tag)
                      clean_payload = b_data[1:]

                  # 3. PADDING (Scapy CRC fix)
                  # Dodajemo 4 nule da budemo sigurni da ne pojede kraj poruke
                  final_packet = clean_payload + b"\x00\x00\x00\x00"
                  
                  self.sock.sendto(final_packet, self.dest_addr)
                  
                  # PROVJERA: Mora početi s '40'
                  print(f"[UDP] Poslano: {final_packet.hex()}")
                  
              except Exception as e:
                  print(f"[UDP] Greška: {e}")
    ip: '"127.0.0.1"'
    port: '40868'
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: '500000'
    sf: '7'
    soft_decoding: 'True'
    sync_word: '[0x34]'
  states: {}
- name: lora_rx_0_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: '500000'
    sf: '8'
    soft_decoding: 'True'
    sync_word: '[0x34]'
  states: {}
- name: lora_rx_0_0_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '1'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: '500000'
    sf: '9'
    soft_decoding: 'True'
    sync_word: '[0x34]'
  states: {}
- name: lora_rx_0_0_1
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '1'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: '500000'
    sf: '10'
    soft_decoding: 'True'
    sync_word: '[0x34]'
  states: {}
- name: lora_rx_0_0_2
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '1'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: '500000'
    sf: '11'
    soft_decoding: 'True'
    sync_word: '[0x34]'
  states: {}
- name: lora_rx_0_0_3
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '1'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: '500000'
    sf: '12'
    soft_decoding: 'True'
    sync_word: '[0x34]'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 868e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 2e6
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: freq_slider
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: channel_freq
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: 868e6
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [Recenter_0, '0', blocks_add_xx_0, '0']
- [Recenter_0_0, '0', blocks_add_xx_0, '1']
- [Recenter_0_0_0, '0', blocks_add_xx_0, '2']
- [Recenter_0_0_0_0, '0', blocks_add_xx_0, '3']
- [Recenter_0_0_0_0_0, '0', blocks_add_xx_0, '4']
- [Recenter_0_1, '0', blocks_add_xx_0, '5']
- [Recenter_0_1_0, '0', blocks_add_xx_0, '6']
- [Recenter_0_1_0_0, '0', blocks_add_xx_0, '7']
- [Recenter_0_1_0_0_0, '0', blocks_add_xx_0, '8']
- [Recenter_0_1_0_0_0_0, '0', blocks_add_xx_0, '9']
- [blocks_add_xx_0, '0', lora_rx_0, '0']
- [blocks_add_xx_0, '0', lora_rx_0_0, '0']
- [blocks_add_xx_0, '0', lora_rx_0_0_0, '0']
- [blocks_add_xx_0, '0', lora_rx_0_0_1, '0']
- [blocks_add_xx_0, '0', lora_rx_0_0_2, '0']
- [blocks_add_xx_0, '0', lora_rx_0_0_3, '0']
- [lora_rx_0, out, epy_block_0, msg_in]
- [lora_rx_0_0, out, epy_block_0, msg_in]
- [lora_rx_0_0_0, out, epy_block_0, msg_in]
- [lora_rx_0_0_1, out, epy_block_0, msg_in]
- [lora_rx_0_0_2, out, epy_block_0, msg_in]
- [lora_rx_0_0_3, out, epy_block_0, msg_in]
- [osmosdr_source_0, '0', Recenter_0, '0']
- [osmosdr_source_0, '0', Recenter_0_0, '0']
- [osmosdr_source_0, '0', Recenter_0_0_0, '0']
- [osmosdr_source_0, '0', Recenter_0_0_0_0, '0']
- [osmosdr_source_0, '0', Recenter_0_0_0_0_0, '0']
- [osmosdr_source_0, '0', Recenter_0_1, '0']
- [osmosdr_source_0, '0', Recenter_0_1_0, '0']
- [osmosdr_source_0, '0', Recenter_0_1_0_0, '0']
- [osmosdr_source_0, '0', Recenter_0_1_0_0_0, '0']
- [osmosdr_source_0, '0', Recenter_0_1_0_0_0_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', Recenter_0, '0']
- [soapy_rtlsdr_source_0, '0', Recenter_0_0, '0']
- [soapy_rtlsdr_source_0, '0', Recenter_0_0_0, '0']
- [soapy_rtlsdr_source_0, '0', Recenter_0_0_0_0, '0']
- [soapy_rtlsdr_source_0, '0', Recenter_0_0_0_0_0, '0']
- [soapy_rtlsdr_source_0, '0', Recenter_0_1, '0']
- [soapy_rtlsdr_source_0, '0', Recenter_0_1_0, '0']
- [soapy_rtlsdr_source_0, '0', Recenter_0_1_0_0, '0']
- [soapy_rtlsdr_source_0, '0', Recenter_0_1_0_0_0, '0']
- [soapy_rtlsdr_source_0, '0', Recenter_0_1_0_0_0_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
